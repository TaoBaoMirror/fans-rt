# Keil uVision project Libstm32.uvproj, settings and files
target Libstm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Libstm32 (library)
  AfterMake: .\copylib.bat ..\..\objects\libstm32\libstm32.lib ..\..\libs\thumb\libfw.a
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Platform\libfw\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\include;..\..\Source\Platform\libfw;..\..\source\include\armcc;..\..\source\include\stdc;..\..\source\include\stm32\mini;..\..\source\platform\board\stm32\mini;..\..\source\system\core
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group libfw
    ../../Source/Platform/libfw/stm32f10x/: fwtick.c
    ../../Source/platform/libfw/stm32f10x/compiler/arm/: libfw.s
  group STM32F10x_StdPeriph_Driver
    ../../Source/Platform/libfw/stm32f10x/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../Source/Platform/libfw/stm32f10x/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../../Source/Platform/libfw/stm32f10x/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../Source/Platform/libfw/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x_conf.h stm32f10x.h system_stm32f10x.h
