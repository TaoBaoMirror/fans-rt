# Keil uVision project stm32-tiny.uvproj, settings and files
target stm32-tiny (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-tiny +hex
  BeforeMake: ..\..\source\script\win32\keil.cmd ARCH=stm32 BOARD=tiny COMPILER=armcc
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__LITTLE_ENDIAN__,__DEBUG__,ARCH=STM32
  c misc: --c99
  c include: ..\..\Source\include;..\..\source\include\stdc;..\..\source\include\armcc;..\..\Source\include\stm32;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Platform\libfw\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\system\core;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\Source\Platform\board\stm32\tiny;..\..\source\libs\libcmini;..\..\source\libs\libcal;..\..\source\platform\arch\stm32;..\..\source\platform\libfw\stm32f10x;..\..\source\testcode\tiny;..\..\source\testcode;..\..\source\system\core\stack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: ..\..\source\platform\board\stm32\tiny\armcc\stm32-tiny.sct
  link misc: --userlibpath "..\..\libs\thumb" libfw.a
  group include
    ../../source/include/: fadebug.h fadefs.h faerror.h famodule.h fapi.h fatypes.h fauser.h facore.h
  group core
    ../../source/system/core/: kcore.h kdebug.c kdebug.h khash.c kipc.c kipc.h kirq.c kirq.h klist.h klpc.c klpc.h kmem.c kmem.h kmisc.c kobject.c kobject.h kpool.c kpool.h kprintf.c kstartup.c ktable.c ktable.h ktask.c ktask.h ktentry.c ktick.c ktick.h readme.txt schedule.h kstack.c klsot.c klsot.h
    ../../source/system/core/stack/: kstack.h static_stack.c
  group testcode
    ../../source/testcode/: main.c testbase.c testcode.h testipc.c testtask.c testlsot.c
    ../../source/testcode/stm32/tiny/: amodule.c
  group board
    ../../source/platform/board/stm32/tiny/: kirq_define.ini config.h kboard.h khash.h
    ../../source/platform/libfw/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s
    ../../source/platform/board/stm32/: kbstm32_misc.c kbstm32_stack.c kbstm32_init.c
    ../../source/platform/board/: kbcom_stack.c
    ../../source/platform/board/stm32/tiny/armcc/: kboard_interrupt.s
  group libapi
    ../../source/libs/libapi/: uipc.c umem.c uobject.c utask.c utick.c libapi.h ulsot.c
  group libc
    ../../source/libs/libcmini/: csprintf.c libcmini.h libcstr.h memory.c string.c stringw.c tsprintf.h wsprintf.c
    ../../source/libs/libcuser/: fprintf.c fprintf.h fputc.c stdio.c wfprintf.c
  group stdc
    ../../source/include/stdc/: stdio.h stdlib.h string.h wchar.h
  group libcal
    ../../source/libs/libcal/: cadebug.c cadebug.h camms.c camodule.c caobject.c castack.c catask.c catick.c libcal.h request.c request.h utentry.c calsot.c
  group arch
    ../../source/platform/arch/stm32/: karch.h karch_init.c karch_main.c karch_misc.c karch_stack.c
    ../../source/platform/arch/stm32/arm/: karch_armasm_misc.s karch_armasm_stack.s karch_micro_stack.s
