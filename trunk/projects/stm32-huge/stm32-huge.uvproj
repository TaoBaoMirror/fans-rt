# Keil uVision project stm32-huge.uvproj, settings and files
target stm32-huge (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-huge +hex
  BeforeMake: C:\mgw_x86so\msys\1.0\bin\make.exe -C ../../source/build -f keil.mak ARCH=stm32 BOARD=huge COMPILER=armcc
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__DEBUG__,__LITTLE_ENDIAN__,ARCH=STM32
  c misc: --c99
  c include: ..\..\Source\include;..\..\source\include\stdc;..\..\source\include\armcc;..\..\Source\include\stm32;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Platform\libfw\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\system\core;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\Source\Platform\board\stm32\huge;..\..\source\libs\libcmini;..\..\source\libs\libcal;..\..\source\platform\arch\stm32;..\..\source\platform\libfw\stm32f10x;..\..\source\testcode;..\..\source\system\core\stack
  asm define: DEBUG_IRQ_MONITOR,CONFIG_ARCH_SUPPORT_KSTACK
  asm include: ..\..\source\platform\board\stm32\huge\armcc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\source\platform\board\stm32\huge\armcc\stm32-huge.sct
  link misc: --userlibpath "..\..\libs\thumb" libfw.a
  group include
    ../../source/include/: fadebug.h fadefs.h faerror.h famodule.h fapi.h fapp.h fatypes.h version.h
    ../../source/include/stdc/: stdio.h stdlib.h string.h wchar.h
    ../../source/include/armcc/: compiler.h limits.h stdarg.h stddef.h stdint.h
  group core
    ../../source/system/core/: kcore.h kdebug.c kdebug.h kipc.c kipc.h kirq.c kirq.h klist.h klpc.c klpc.h kmem.c kmem.h kmisc.c kobject.c kobject.h kpool.c kpool.h kprintf.c kstartup.c ktable.c ktable.h ktask.c ktask.h ktick.c ktick.h readme.txt khash.c ktentry.c schedule.h
    ../../source/system/core/stack/: kstack.h static_stack.c
  group testcode
    ../../source/testcode/: testtask.c main.c tasktest.c testbase.c testcode.h testipc.c
    ../../source/testcode/stm32/huge/: amodule.c
  group board
    ../../source/platform/board/: kbcom_stack.c
    ../../source/platform/board/stm32/: kbstm32_stack.c kbstm32_init.c kbstm32_misc.c
    ../../source/platform/board/stm32/huge/: readme.txt config.h kboard.h khash.h kboard_memory.c
    ../../source/platform/board/stm32/huge/armcc/: kbhuge_interrupt.s
  group arch
    ../../source/platform/arch/stm32/: karch.h karch_init.c karch_main.c karch_misc.c karch_stack.c
    ../../source/platform/libfw/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../source/platform/arch/stm32/arm/: karch_armasm_misc.s karch_armasm_stack.s karch_micro_stack.s
  group libapi
    ../../source/libs/libapi/: uipc.c umem.c utask.c utick.c uobject.c
  group libc
    ../../source/libs/libcuser/: fprintf.c fprintf.h fputc.c stdio.c wfprintf.c
    ../../source/libs/libcmini/: csprintf.c libcmini.h libcstr.h memory.c string.c stringw.c tsprintf.h wsprintf.c
  group libcal
    ../../source/libs/libcal/: cadebug.c cadebug.h camms.c camodule.c caobject.c castack.c catask.c catick.c libcal.h request.c request.h utentry.c
