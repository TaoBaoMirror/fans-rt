# Keil uVision project stm32-alientek.uvproj, settings and files
target stm32-alientek (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-alientek +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe   --bin -o     --bin -o  ..\..\Object\Fans-RT\Fans-RT.bin ..\..\Object\Fans-RT\Fans-RT.axf
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__DEBUG__, __LITTLE_ENDIAN__
  c include: ..\..\Source\include;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Platform\libfw\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\include\stm32;..\..\Source\system\core;..\..\Source\Platform\bsp\stm32\huge;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\CoreSupport
  asm include: ..\..\Source\Platform\bsp\stm32\huge
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --userlibpath "..\..\Libs" Libfw.lib
  group include
    ../../Source/include/: fansapi.h fansapp.h fanscore.h fansdebug.h fansdefs.h fanserror.h fanslist.h fanstypes.h famodule.h
    ../../Source/include/stm32/: libfw.h fanshal.h
  group core
    ../../Source/system/core/: syscall.c corebug.c coreirq.c coremem.c coremod.c corentry.c coreobj.c coreobj.h corepool.c corepool.h coretab.c coretab.h coretask.c coretask.h coretick.c make_version.bat readme.txt scheduler.c version.bat version.h
  group bsp
    ../../Source/Platform/bsp/stm32/huge/: bsp_api.h bsp_irq.h bsp_irq.inc bspcore.c bspgpio.c bspusart.c config.h config.ini modules.h
  group testcode
    ../../Source/testcode/mini/: tasktest.c
  group libapi
    ../../Source/user/libapi/: coreapi.c libapi.h mmsapi.c tssapi.c tsscall.c
  group hal
    ../../Source/Platform/hal/stm32/: stm32fault.c stm32hal.c stm32hal.h stm32nvic.c stm32rcc.c stm32stack.c
    ../../Source/Platform/hal/stm32/arm/: fault_entry.s saveirq.inc startup_stm32f10x_md.s stm32misc.s svc_entry.s systick_entry.s
