# Keil uVision project stm32-soft.uvproj, settings and files
target stm32-soft (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-soft +hex
  BeforeMake: ..\..\source\script\win32\keil.cmd ARCH=stm32 BOARD=soft COMPILER=armcc
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__DEBUG__,__LITTLE_ENDIAN__,ARCH=STM32
  c misc: --c99
  c include: ..\..\Source\include;..\..\source\include\stdc;..\..\source\include\armcc;..\..\Source\include\stm32;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Platform\libfw\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\system\core;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\Source\Platform\board\stm32\soft;..\..\source\libs\libcmini;..\..\source\libs\libcal;..\..\source\platform\arch\stm32;..\..\source\platform\libfw\stm32f10x;..\..\source\testcode;..\..\source\system\core\stack
  asm include: ..\..\source\platform\board\stm32\soft\armcc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\source\platform\board\stm32\soft\armcc\stm32-soft.sct
  link misc: --userlibpath "..\..\libs\thumb" libfw.a
  group include
    ../../source/include/armcc/: compiler.h limits.h stdarg.h stddef.h stdint.h
    ../../source/include/: facore.h fadebug.h fadefs.h faerror.h famodule.h fapi.h fatypes.h fauser.h
    ../../source/include/stdc/: stdio.h stdlib.h string.h wchar.h
  group core
    ../../source/system/core/: kcore.h kdebug.c kdebug.h khash.c kipc.c kipc.h kirq.c kirq.h klist.h klpc.c klpc.h kmem.c kmem.h kmisc.c kobject.c kobject.h kpool.c kpool.h kprintf.c kstack.c kstartup.c ktable.c ktable.h ktask.c ktask.h ktentry.c ktick.c ktick.h readme.txt schedule.h klsot.c klsot.h
    ../../source/system/core/stack/: dynamic_stack.c kstack.h static_stack.c
  group testcode
    ../../source/testcode/: testtask.c main.c testbase.c testcode.h testlsot.c testevent.c testmutex.c testsemaphore.c testsemset.c
    ../../source/testcode/stm32/soft/: amodule.c
  group board
    ../../source/platform/board/: kbcom_stack.c
    ../../source/platform/board/stm32/: kbstm32_init.c kbstm32_misc.c kbstm32_stack.c
    ../../source/platform/board/stm32/soft/: config.h kboard.h kboard_memory.c khash.h
    ../../source/platform/board/stm32/soft/armcc/: kboard_interrupt.s
  group arch
    ../../source/platform/arch/stm32/: karch.h karch_init.c karch_main.c karch_misc.c karch_stack.c karch_debug.c
    ../../source/platform/arch/stm32/arm/: karch_armasm_misc.s karch_armasm_stack.s karch_micro_stack.s
    ../../source/platform/libfw/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group libapi
    ../../source/libs/libapi/: uipc.c umem.c uobject.c utask.c utick.c ulsot.c libapi.h
  group libc
    ../../source/libs/libcuser/: wfprintf.c fprintf.c fprintf.h fputc.c stdio.c
    ../../source/libs/libcmini/: csprintf.c libcmini.h libcstr.h memory.c string.c stringw.c tsprintf.h wsprintf.c
  group libcal
    ../../source/libs/libcal/: cadebug.c cadebug.h camms.c camodule.c caobject.c castack.c catask.c libcal.h request.c request.h utentry.c catick.c calsot.c
