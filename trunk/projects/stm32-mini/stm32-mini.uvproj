# Keil uVision project stm32-mini.uvproj, settings and files
target stm32-mini (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-mini
  BeforeMake: C:\mgw_x86so\msys\1.0\bin\make.exe -C ../../source/build -f keil.mak ARCH=stm32 BOARD=mini COMPILER=armcc
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__LITTLE_ENDIAN__,__DEBUG__,ARCH=STM32
  c misc: --c99
  c include: ..\..\Source\include;..\..\source\include\stdc;..\..\source\include\armcc;..\..\Source\include\stm32;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Platform\libfw\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\system\core;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\Source\Platform\board\stm32\mini;..\..\source\libs\libcmini;..\..\source\libs\libcal;..\..\source\platform\arch\stm32;..\..\source\platform\libfw\stm32f10x;..\..\source\testcode\mini
  asm include: ..\..\source\platform\board\stm32\mini\armcc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\source\platform\board\stm32\mini\armcc\stm32-mini.sct
  link misc: --userlibpath "..\..\libs\thumb" libfw.a
  group include
    ../../Source/include/: fadefs.h faerror.h famodule.h fapi.h fapp.h fatypes.h
    ../../source/include/: fadebug.h version.h
  group core
    ../../Source/system/core/: kdebug.c kirq.c kobject.h kpool.c kpool.h kstartup.c ktask.c ktask.h ktick.c ktick.h readme.txt kobject.c kprintf.c
    ../../source/system/core/: klpc.c kirq.h klpc.h kmem.c kmisc.c kcore.h kdebug.h kmem.h klist.h kipc.c kipc.h ktable.c ktable.h
  group testcode
    ../../source/testcode/stm32/: amodule.c main.c tasktest.c testbase.c testcode.h testipc.c testtask.c
  group board
    ../../Source/Platform/board/stm32/mini/: bspcore.c bspusart.c
    ../../Source/platform/libfw/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../source/platform/board/stm32/mini/: config.h kboard.h config.mak birq.ini birq.h khash.h
  group arch
    ../../Source/Platform/arch/stm32/: stm32nvic.c stm32rcc.c stm32fault.c stm32hal.c stm32hal.h
    ../../Source/Platform/arch/stm32/arm/: saveirq.inc stm32misc.s
    ../../source/platform/arch/stm32/arm/: stm32stack.c stm32_bootstack.s
    ../../source/platform/arch/stm32/arm/stack_model/: stm32_single_sw.s
  group libapi
    ../../source/libs/libapi/: umem.c utask.c utick.c uipc.c
  group libc
    ../../Source/libs/libcmini/: string.c
    ../../source/libs/libcmini/: libcmini.h stringw.c memory.c libcstr.h tsprintf.h wsprintf.c csprintf.c
    ../../source/libs/libcuser/: fprintf.c fputc.c stdio.c
  group stdc
    ../../source/include/stdc/: stdio.h stdlib.h string.h
  group libcal
    ../../source/libs/libcal/: cadebug.c cadebug.h camms.c caobject.c catask.c catick.c libcal.h request.c request.h camodule.c
