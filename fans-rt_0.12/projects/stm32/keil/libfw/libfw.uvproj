# Keil uVision project libfw.uvproj, settings and files
target libfw (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: libfw (library)
  AfterMake: ..\..\..\..\source\script\keil\libfw.bat
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\source\platform\stm32\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\source\platform\stm32\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\source\platform\stm32\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\source\include;..\..\..\..\source\include\armcc;..\..\..\..\source\include\stdc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sources
    ../../../../source/platform/stm32/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../../source/platform/stm32/stm32f10x/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../source/platform/stm32/stm32f10x/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group include
    ../../../../source/platform/stm32/stm32f10x/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../../../source/platform/stm32/stm32f10x/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h
    ../../../../source/platform/stm32/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.h
