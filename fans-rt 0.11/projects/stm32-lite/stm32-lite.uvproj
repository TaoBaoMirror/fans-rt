# Keil uVision project stm32-lite.uvproj, settings and files
target stm32-lite (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-lite +hex
  BeforeMake: ..\..\source\script\win32\keil.cmd ARCH=stm32 BOARD=lite COMPILER=armcc
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__DEBUG__,__LITTLE_ENDIAN__,ARCH=STM32,CONFIG_ARCH_SUPPORT_KSTACK=TRUE
  c misc: --c99
  c include: ..\..\Source\include;..\..\source\include\stdc;..\..\source\include\armcc;..\..\Source\include\stm32;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Platform\libfw\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\system\core;..\..\Source\Platform\libfw\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\Source\Platform\board\stm32\lite;..\..\source\libs\libcmini;..\..\source\libs\libcal;..\..\source\platform\arch\stm32;..\..\source\platform\libfw\stm32f10x;..\..\source\testcode;..\..\source\system\core\stack
  asm define: DEBUG_IRQ_MONITOR,CONFIG_ARCH_SUPPORT_KSTACK
  asm include: ..\..\source\platform\board\stm32\lite\armcc;..\..\source\platform\arch\stm32\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\source\platform\board\stm32\lite\armcc\stm32-lite.sct
  link misc: --userlibpath "..\..\libs\thumb" libfw.a
  group include
    ../../source/include/: fadefs.h faerror.h famodule.h fapi.h fatypes.h version.h fadebug.h
    ../../source/include/stdc/: stdio.h stdlib.h string.h wchar.h
    ../../source/include/armcc/: compiler.h limits.h stdarg.h stddef.h stdint.h
  group core
    ../../source/system/core/: kcore.h kdebug.c kdebug.h kirq.c kirq.h klist.h klpc.c klpc.h kmem.c kmem.h kmisc.c kobject.c kobject.h kpool.c kpool.h kprintf.c kstartup.c ktable.c ktable.h ktask.c ktask.h ktick.c ktick.h readme.txt kipc.c schedule.h khash.c ktentry.c kstack.c klsot.c kipc.h
    ../../source/system/core/stack/: static_stack.c kstack.h dynamic_stack.c
  group testcode
    ../../source/testcode/: testcode.h testtask.c main.c testbase.c testlsot.c testevent.c testmutex.c testsemaphore.c testsemset.c
    ../../source/testcode/stm32/lite/: amodule.c
  group board
    ../../source/platform/board/stm32/lite/: config.h config.mak kboard.h khash.h kboard_memory.c
    ../../source/platform/libfw/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../source/platform/board/: kbcom_stack.c
    ../../source/platform/board/stm32/: kbstm32_misc.c kbstm32_init.c kbstm32_stack.c
    ../../source/platform/board/stm32/lite/armcc/: kboard_interrupt.s
  group libapi
    ../../source/libs/libapi/: umem.c utask.c utick.c uipc.c uobject.c ulsot.c libapi.h
  group libc
    ../../source/libs/libcmini/: csprintf.c libcmini.h libcstr.h memory.c string.c stringw.c tsprintf.h wsprintf.c
    ../../source/libs/libcuser/: fprintf.c fputc.c stdio.c wfprintf.c
  group libcal
    ../../source/libs/libcal/: cadebug.c cadebug.h camms.c caobject.c catask.c catick.c libcal.h request.c request.h camodule.c castack.c utentry.c calsot.c
  group arch
    ../../source/platform/arch/stm32/: karch.h karch_init.c karch_main.c karch_stack.c karch_misc.c karch_debug.c
    ../../source/platform/arch/stm32/arm/: karch_armasm_misc.s karch_armasm_stack.s
